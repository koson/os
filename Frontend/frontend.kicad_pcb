# Repository koson/os

File README.md:

# os-backplane
This is the backplane for my very long oscilloscope
project.

## KiCad design Frontend/frontend.kicad_pcb

Schematic: frontend.sch, OS-1 Oscilloscope Frontend - Dual Channel

Parts:
DZ2: 40V
E1: 120; RESC3216X60
J1, J3: SATA; CONN-MOLEX-0678005001
J2, J6: BNC; CONN-BNC-1-1337543-0
J9: PCIEx4 EDGE; CONN-10018784-10201TLF-PCIEx4-FCI
K7: RELAY_DPDT
Q2: NPNDARL2
R129: R
TP8: +5; TEST-SMD-SMALL
TP9: -5; TEST-SMD-SMALL
TP10: +3.3A; TEST-SMD-SMALL

Connections:
+3.3A: TP10.1; also elsewhere on the board
+5: TP8.1; also elsewhere on the board
/3V3SB: E1.2, J9.B10
/Channel1/INPUT: J2.1; also elsewhere on the board
/Channel1/VOCM: J1.6 (A-); also elsewhere on the board
/Channel1/VO_N: J1.3 (A-); also elsewhere on the board
/Channel1/VO_P: J1.2 (A+); also elsewhere on the board
/Channel2/INPUT: J6.1; also elsewhere on the board
/Channel2/VOCM: J3.6 (A-); also elsewhere on the board
/Channel2/VO_N: J3.3 (A-); also elsewhere on the board
/Channel2/VO_P: J3.2 (A+); also elsewhere on the board
/Microcontroller/#IRQ: J9.B11; also elsewhere on the board
/Microcontroller/#PERST: J9.A11; also elsewhere on the board
/Microcontroller/#SS: J9.A8; also elsewhere on the board
/Microcontroller/MISO: J9.A7; also elsewhere on the board
/Microcontroller/MOSI: J9.A6; also elsewhere on the board
/Microcontroller/SCK: J9.A5; also elsewhere on the board
/Microcontroller/SCL: J9.B6; also elsewhere on the board
/Microcontroller/SDA: J9.B5; also elsewhere on the board

Notes on the sheet:
#PRSNT
The system design requires the card-identifying I2C device to be powered from 3V3SB. On this card, the main microcontroller performs this function. Because the load on the 3V3 rail here is so small, we're using 3V3SB as the main 3V3 rail for simplicity. Unused edge contacts A9,A10,B8,B9 are the mas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

Parts:
C1: 1u; CAPC2012X70
C2: 6p8; CAPC1608X55
C3, C7: 4p7 1kV; CAPC2828X260
C4: 1n 2kV; CAPC4520X168
C5: 22n 630V; MANUF-PANASONIC-ECQ-EF
C6, C8: 10p 1kV; CAPC3216X70
C9: 120p; CAPC2012X70
C11, C12: TBD; CAPC1005X55
C13, C31, C39: 100n; CAPC1608X55
C14: 33u/16; CAPMP7343X310
C15, C16, C17, C18, C20, C21, C22, C23, C24, C32: 100n; CAPC1220X107
C25, C26, C27, C28, C29, C30, C33, C34, C35, C36, C37, C38: 10n; CAPC1005X55
CV1, CV3: 30p; MURATA-TZC3P
CV2, CV4: 30p
D1, D2, D3: BAV99W; SC-70
GDT1: 400V; BOURNS-GDT-2051
K1, K3: HE3600; HAMLIN-HE3600
K2: EE2-5NU; KEMET-EE2-xNU
R1, R2: 64R9; RESC1608X50
R3: 1M; RESC1608X50
R4, R34: 35R7; RESC1005X40
R5, R6, R7: 332k; RESC2012X50
R8, R9, R10: 523k; RESC2012X50
R11: 100k; RESC1608X50
R12, R19, R25: 10M; RESC1608X50
R13, R14, R21, R22, R24, R26: 357k; RESC2012X50
R15, R16, R17, R18: 200; RESC3216X60
R20: 3k3; RESC1005X40
R23: 10k; RESC1005X40
R27, R39: 220; RESC1005X40
R28, R31, R40, R43: 442; RESC1005X40
R29, R41: 49R9; RESC1005X40
R30: 165; RESC1005X40
R32, R35: 64R9; RESC1005X40
R33, R36: 300; RESC1005X40
R37, R38: TBD; RESC1005X40
R42: 120k; RESC1005X40
R44: 30k; RESC1005X40
R67: 20k; RESC1005X40
TP4: BUFFER; TEST-SMD-SMALL
TP6: S1; TEST-SMD-SMALL
TP11, TP13: S2; TEST-SMD-SMALL
U1: MCP9700T-E/TT; SOT-23
U2: ADA4817-1ACPZ; ANALOG-LFCSP_VD-8
U3, U4, U5: MAX4567EEE; SOP63P600X160-16
U6: AD8003ACPZ; QFN50P400X400X80-25
U7: LMH6552SD; PSON50P300X250X80-9
U8: MC33078DGK; SOP65P490X109-8

Connections:
+2.5: R67.2; also elsewhere on the board
+5: C1.1, C14.1, C15.1, C16.1, C17.1, C18.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, D2.2, D3.2, R42.1, U1.1 (V+), U2.1 (~SHDN), U2.8 (V+), U3.7 (V+), U3.15 (V+), U4.7 (V+), U4.15 (V+), U5.7 (V+), U5.15 (V+), U6.1 (V+1), U6.18 (V+3), U6.19 (V+2), U7.3 (V+), U7.7 (EN); also elsewhere on the board
/Channel1/#ATT1: K2.C2; also elsewhere on the board
/Channel1/#DC: K1.A; also elsewhere on the board
/Channel1/#TERM: K3.A; also elsewhere on the board
/Channel1/ATT2: U3.1 (IN1); also elsewhere on the board
/Channel1/INPUT: GDT1.1, K3.P1A, R4.2; also elsewhere on the board
/Channel1/VOCM: R42.2, R43.2, R44.1; also elsewhere on the board
/Channel1/VOS1: R11.2; also elsewhere on the board
/Channel1/VOS2: R12.2; also elsewhere on the board
/Channel1/VOS3: R23.2; also elsewhere on the board
/Channel1/VO_N: R41.1; also elsewhere on the board
/Channel1/VO_P: R29.1; also elsewhere on the board
/Microcontroller/CH1_GAIN1: U5.1 (IN1), U5.9 (IN2); also elsewhere on the board
/Microcontroller/CH1_GAIN2: U4.1 (IN1), U4.9 (IN2); also elsewhere on the board
/Microcontroller/CH1_TEMP: U1.2 (OUT); also elsewhere on the board
unnamed: C2.1, CV1.2
unnamed: C2.2, R1.1
unnamed: C3.1, R2.2
unnamed: C3.2, C6.1, K2.P2CO, R5.2
unnamed: C4.1, C5.1, D1.3, K1.P1A, R1.2, R3.2, R11.1, R12.1, U2.3 (IN-)
unnamed: C4.2, C5.2, K1.P1B, R2.1, R7.1
unnamed: C6.2, CV2.1, R19.1
unnamed: C7.1, C9.1, CV3.1, K2.P2A, R10.1, R14.1
unnamed: C7.2, C8.1, K2.P1A, R8.2, R13.1
unnamed: C8.2, CV4.1, R25.1
unnamed: C11.1, R37.2
unnamed: C12.1, R38.2
unnamed: C13.1, D2.3, R43.1, U8.3 (IN+)
unnamed: CV1.1, R3.1, U2.2 (FB)
unnamed: D3.3, U7.2 (VCM), U8.1 (OUT), U8.2 (IN-)
unnamed: K2.P1B, K2.P2B
unnamed: K2.P1CO, R4.1
unnamed: K3.P1B, R15.1, R16.1, R17.1, R18.1
unnamed: R5.1, R6.2
unnamed: R6.1, R7.2
unnamed: R8.1, R9.2
unnamed: R9.1, R10.2
unnamed: R13.2, R21.1
unnamed: R14.2, R22.1
unnamed: R21.2, R24.1
unnamed: R22.2, R26.1
unnamed: R23.1, R27.1, R28.2, U7.1 (IN-)
unnamed: R27.2, R31.1, U6.2 (FB)
unnamed: R28.1, R29.2, U7.4 (OUT+)
unnamed: R30.1, TP4.1, U2.7 (OUT), U3.8 (NC1)
unnamed: R30.2, R34.1, U3.2 (NO1)
unnamed: R31.2, U6.3 (IN-)
unnamed: R32.1, R33.2, R37.1, U6.16 (IN-)
unnamed: R33.1, U6.17 (FB)
unnamed: R35.1, R36.2, R38.1, U6.21 (IN-)
unnamed: R36.1, U6.20 (FB)
unnamed: R39.1, R40.2, R67.1, U7.8 (IN+)
unnamed: R40.1, R41.2, U7.5 (OUT-)
unnamed: TP6.1, U3.5 (COM1), U5.2 (NO1), U5.10 (NC2)
unnamed: TP11.1, U4.2 (NO1), U4.10 (NC2), U5.13 (COM2)
unnamed: TP13.1, U4.13 (COM2), U6.4 (IN+)
unnamed: U4.5 (COM1), U6.22 (IN+)
unnamed: U4.16 (NO2), U6.10 (OUT)
unnamed: U5.5 (COM1), U6.15 (IN+)
unnamed: U5.16 (NO2), U6.12 (OUT)
unnamed: U8.6 (IN-), U8.7 (OUT)
VRELAY: K1.K, K2.C1, K3.K; also elsewhere on the board

Parts of its further copies:
C40: 1u; CAPC2012X70
C41: 6p8; CAPC1608X55
C42, C46: 4p7 1kV; CAPC2828X260
C43: 1n 2kV; CAPC4520X168
C44: 22n 630V; MANUF-PANASONIC-ECQ-EF
C45, C47: 10p 1kV; CAPC3216X70
C50, C51: TBD; CAPC1005X55
C52, C70, C78: 100n; CAPC1608X55
C53: 33u/16; CAPMP7343X310
C54, C55, C56, C57, C59, C60, C61, C62, C63, C71: 100n; CAPC1220X107
C64, C65, C66, C67, C68, C69, C72, C73, C74, C75, C76, C77: 10n; CAPC1005X55
CV5, CV7: 30p; MURATA-TZC3P
CV6, CV8: 30p
D4, D5, D6: BAV99W; SC-70
GDT2: 400V; BOURNS-GDT-2051
K4, K6: HE3600; HAMLIN-HE3600
K5: EE2-5NU; KEMET-EE2-xNU
R45, R46: 64R9; RESC1608X50
R47: 1M; RESC1608X50
R48, R78: 35R7; RESC1005X40
R49, R50, R51: 332k; RESC2012X50
R55: 100k; RESC1608X50
R56, R63, R69: 10M; RESC1608X50
R57, R58, R65, R66, R68, R70: 357k; RESC2012X50
R59, R60, R61, R62: 200; RESC3216X60
R64: 3k3; RESC1005X40
R71, R83: 220; RESC1005X40
R72, R75, R84, R87: 442; RESC1005X40
R73, R85: 49R9; RESC1005X40
R74: 165; RESC1005X40
R76, R79: 64R9; RESC1005X40
R77, R80: 300; RESC1005X40
R81, R82: TBD; RESC1005X40
R86: 120k; RESC1005X40
R88: 30k; RESC1005X40
R153: 10k; RESC1005X40
R154: 20k; RESC1005X40
TP5: BUFFER; TEST-SMD-SMALL
TP7: S1; TEST-SMD-SMALL
TP12, TP14: S2; TEST-SMD-SMALL
U9: MCP9700T-E/TT; SOT-23
U10: ADA4817-1ACPZ; ANALOG-LFCSP_VD-8
U11, U12, U13: MAX4567EEE; SOP63P600X160-16
U14: AD8003ACPZ; QFN50P400X400X80-25
U15: LMH6552SD; PSON50P300X250X80-9
U16: MC33078DGK; SOP65P490X109-8

Connections of its further copies:
+2.5: R154.2; also elsewhere on the board
+5: C40.1, C53.1, C54.1, C55.1, C56.1, C57.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, D5.2, D6.2, R86.1, U9.1 (V+), U10.1 (~SHDN), U10.8 (V+), U11.7 (V+), U11.15 (V+), U12.7 (V+), U12.15 (V+), U13.7 (V+), U13.15 (V+), U14.1 (V+1), U14.18 (V+3), U14.19 (V+2), U15.3 (V+), U15.7 (EN); also elsewhere on the board
/Channel2/#ATT1: K5.C2; also elsewhere on the board
/Channel2/#DC: K4.A; also elsewhere on the board
/Channel2/#TERM: K6.A; also elsewhere on the board
/Channel2/ATT2: U11.1 (IN1); also elsewhere on the board
/Channel2/INPUT: GDT2.1, K6.P1A, R48.2; also elsewhere on the board
/Channel2/VOCM: R86.2, R87.2, R88.1; also elsewhere on the board
/Channel2/VOS1: R55.2; also elsewhere on the board
/Channel2/VOS2: R56.2; also elsewhere on the board
/Channel2/VOS3: R153.2; also elsewhere on the board
/Channel2/VO_N: R85.1; also elsewhere on the board
/Channel2/VO_P: R73.1; also elsewhere on the board
/Microcontroller/CH2_GAIN1: U13.1 (IN1), U13.9 (IN2); also elsewhere on the board
/Microcontroller/CH2_GAIN2: U12.1 (IN1), U12.9 (IN2); also elsewhere on the board
/Microcontroller/CH2_TEMP: U9.2 (OUT); also elsewhere on the board
unnamed: C41.1, CV5.2
unnamed: C41.2, R45.1
unnamed: C42.1, R46.2
unnamed: C42.2, C45.1, K5.P2CO, R49.2
unnamed: C43.1, C44.1, D4.3, K4.P1A, R45.2, R47.2, R55.1, R56.1, U10.3 (IN-)
unnamed: C43.2, C44.2, K4.P1B, R46.1, R51.1
unnamed: C45.2, CV6.1, R63.1
unnamed 92: C46.1, CV7.1, K5.P2A, R58.1; also elsewhere on the board
unnamed 93: C46.2, C47.1, K5.P1A, R57.1; also elsewhere on the board
unnamed: C47.2, CV8.1, R69.1
unnamed: C50.1, R81.2
unnamed: C51.1, R82.2
unnamed: C52.1, D5.3, R87.1, U16.3 (IN+)
unnamed: CV5.1, R47.1, U10.2 (FB)
unnamed: D6.3, U15.2 (VCM), U16.1 (OUT), U16.2 (IN-)
unnamed: K5.P1B, K5.P2B
unnamed: K5.P1CO, R48.1
unnamed: K6.P1B, R59.1, R60.1, R61.1, R62.1
unnamed: R49.1, R50.2
unnamed: R50.1, R51.2
unnamed: R57.2, R65.1
unnamed: R58.2, R66.1
unnamed: R65.2, R68.1
unnamed: R66.2, R70.1
unnamed: R71.2, R75.1, U14.2 (FB)
unnamed: R72.1, R73.2, U15.4 (OUT+)
unnamed: R74.1, TP5.1, U10.7 (OUT), U11.8 (NC1)
unnamed: R74.2, R78.1, U11.2 (NO1)
unnamed: R75.2, U14.3 (IN-)
unnamed: R76.1, R77.2, R81.1, U14.16 (IN-)
unnamed: R77.1, U14.17 (FB)
unnamed: R79.1, R80.2, R82.1, U14.21 (IN-)
unnamed: R80.1, U14.20 (FB)
unnamed: R84.1, R85.2, U15.5 (OUT-)
unnamed: R71.1, R72.2, R153.1, U15.1 (IN-)
unnamed: R83.1, R84.2, R154.1, U15.8 (IN+)
unnamed: TP7.1, U11.5 (COM1), U13.2 (NO1), U13.10 (NC2)
unnamed: TP12.1, U12.2 (NO1), U12.10 (NC2), U13.13 (COM2)
unnamed: TP14.1, U12.13 (COM2), U14.4 (IN+)
unnamed: U12.5 (COM1), U14.22 (IN+)
unnamed: U12.16 (NO2), U14.10 (OUT)
unnamed: U13.5 (COM1), U14.15 (IN+)
unnamed: U13.16 (NO2), U14.12 (OUT)
unnamed: U16.6 (IN-), U16.7 (OUT)
VRELAY: K4.K, K5.C1, K6.K; also elsewhere on the board

Notes on the sheet:
-15dB
+15dB
-30dB
+6dB
-6dB
This capacitor is only present in channel 2.

Parts:
C79, C88: 2u2; CAPMP2013X120
C80, C87: 100n; CAPC1608X55
C81: 15u/16; CAPMP3528X210
C82: 1u; CAPC2012X70
C83, C84, C85, C86, C89: 100n; CAPC1005X55
DS1, DS2, DS3, DS4, DS5, DS6, DS7, DS8, DS9, DS10, DS11, DS12: LED-0603
DZ1: 43V; DIOM5226X203
E2, E3, E6, E7: 600; INDC1005X60
J10: SWD; CONN-100MIL-M-2x5-SHROUD
Q1: ULN2003AD; SOIC127P600X150-16
R89, R100, R107, R108, R109, R110: 10k; RESC1005X40
R90, R92, R93, R94, R95, R96, R97, R98, R99, R101, R102, R103, R104, R105, R106: 3k3; RESC1005X40
R91: 1k; RESC1005X40
R149, R150, R151, R152: 100; RESC1005X40
TP1: INFO; TEST-SMD-SMALL
U17: MAX5725AAUP; SOP65P640X110-20
U18: STM32F030C8T; QFP50P900X900X160-48

Connections:
+3.3A: E2.1, E3.1; also elsewhere on the board
+5: R90.1; also elsewhere on the board
/Channel1/#ATT1: Q1.14; also elsewhere on the board
/Channel1/#DC: Q1.15; also elsewhere on the board
/Channel1/#TERM: Q1.16; also elsewhere on the board
/Channel1/ATT2: R102.1, U18.19 (PB1); also elsewhere on the board
/Channel1/VOS3: U17.2 (OUT0); also elsewhere on the board
/Channel2/#ATT1: Q1.11; also elsewhere on the board
/Channel2/#DC: Q1.12; also elsewhere on the board
/Channel2/#TERM: Q1.13; also elsewhere on the board
/Channel2/ATT2: R104.1, U18.2 (PC13); also elsewhere on the board
/Channel2/VOS3: U17.7 (OUT5); also elsewhere on the board
/Microcontroller/#CSDAC: R89.2, U17.15 (~CS), U18.38 (PA15/#CS_1)
/Microcontroller/#IRQ: U18.16 (PA6); also elsewhere on the board
/Microcontroller/#PERST: U18.17 (PA7); also elsewhere on the board
/Microcontroller/#RST: J10.10, R100.2, U18.7 (#RST)
/Microcontroller/#SS: R108.2, R152.2; also elsewhere on the board
/Microcontroller/CH1_ATT1: Q1.3, R96.1, U18.42 (PB6)
/Microcontroller/CH1_DC: Q1.2, R95.1, U18.43 (PB7)
/Microcontroller/CH1_GAIN1: R101.1, U18.18 (PB0); also elsewhere on the board
/Microcontroller/CH1_GAIN2: R103.1, U18.20 (PB2); also elsewhere on the board
/Microcontroller/CH1_TEMP: U18.11 (PA1/ADC1); also elsewhere on the board
/Microcontroller/CH1_TERM: Q1.1, R94.1, U18.45 (PB8)
/Microcontroller/CH2_ATT1: Q1.6, R99.1, U18.33 (PA12)
/Microcontroller/CH2_DC: Q1.5, R98.1, U18.32 (PA11)
/Microcontroller/CH2_GAIN1: R106.1, U18.4 (PC15); also elsewhere on the board
/Microcontroller/CH2_GAIN2: R105.1, U18.3 (PC14); also elsewhere on the board
/Microcontroller/CH2_TEMP: U18.10 (PA0/ADC0); also elsewhere on the board
/Microcontroller/CH2_TERM: Q1.4, R97.1, U18.31 (PA10)
/Microcontroller/DBG_TX: TP1.1, U18.30 (PA9/TX_1)
/Microcontroller/F_#SS: R152.1, U18.25 (PB12/#CS_2)
/Microcontroller/F_MISO: R150.1, U18.27 (PB14/MISO_2)
/Microcontroller/F_MOSI: R149.1, U18.28 (PB15/MOSI_2)
/Microcontroller/F_SCK: R151.1, U18.26 (PB13/SCK_2)
/Microcontroller/F_SCL: E6.2, R110.2, U18.21 (PB10/SCL_2)
/Microcontroller/F_SDA: E7.2, R109.2, U18.22 (PB11/SDA_2)
/Microcontroller/LevelShifters/VOS1_CH1_IN: U17.4 (OUT2); also elsewhere on the board
/Microcontroller/LevelShifters/VOS1_CH2_IN: U17.5 (OUT3); also elsewhere on the board
/Microcontroller/LevelShifters/VOS2_CH1_IN: U17.3 (OUT1); also elsewhere on the board
/Microcontroller/LevelShifters/VOS2_CH2_IN: U17.6 (OUT4); also elsewhere on the board
/Microcontroller/LevelShifters/VREF_IN: U17.1 (REF(I/O)); also elsewhere on the board
/Microcontroller/MISO: R150.2; also elsewhere on the board
/Microcontroller/MISOINT: U17.12 (DOUT), U18.40 (PB4/MISO_1)
/Microcontroller/MOSI: R149.2; also elsewhere on the board
/Microcontroller/MOSIINT: U17.13 (DIN), U18.41 (PB5/MOSI_1)
/Microcontroller/N5SENSE: R91.2, R93.1, U18.13 (PA3/ADC3)
/Microcontroller/P5SENSE: R90.2, R92.1, U18.12 (PA2/ADC2)
/Microcontroller/SCK: R151.2; also elsewhere on the board
/Microcontroller/SCKINT: U17.14 (SCK), U18.39 (PB3/SCK_1)
/Microcontroller/SCL: E6.1; also elsewhere on the board
/Microcontroller/SDA: E7.1; also elsewhere on the board
/Microcontroller/SWCLK: J10.4, U18.37 (PA14)
/Microcontroller/SWDIO: J10.2, U18.34 (PA13)
/Microcontroller/SWO: J10.6, R107.2
/Microcontroller/TEMP_V5: U18.15 (PA5/ADC5); also elsewhere on the board
/Microcontroller/TEMP_VRELAY: U18.14 (PA4/ADC4); also elsewhere on the board
unnamed: DS1.2, R94.2
unnamed: DS2.2, R95.2
unnamed: DS3.2, R96.2
unnamed: DS4.2, R97.2
unnamed: DS5.2, R98.2
unnamed: DS6.2, R99.2
unnamed: DS7.2, R101.2
unnamed: DS8.2, R102.2
unnamed: DS9.2, R103.2
unnamed: DS10.2, R104.2
unnamed: DS11.2, R105.2
unnamed: DS12.2, R106.2
unnamed: DZ1.1, Q1.9

Parts:
C107, C108, C113, C118: 47u; C-ALUM-5mm
C109, C110, C114, C115: 1u; CAPC2012X70
C111, C116: 330u; C-ALUM-8mm
C112, C117: 100n; CAPC1608X55
D7: US1A; DIOM5326X292
E4, E5: 120; RESC3216X60
J11: APWR; CONN-100MIL-M-1x4-SHROUD
MP1: 217-36CTE6; LAIRD-BMI-S-203
R145: 15 2W; KOASPEER-MOS-2W
R146: 165; RESC1608X50
R147: 620; RESC1608X50
R148: 100k; RESC1608X50
U23: LM317S; TO-263
U24, U27: MCP9700T-E/TT; SOT-23
U25: L78M05CDT; TO-252
U26: TLV70233DSE; TEXAS-S-PWSON-N6
U28: MC79M05CDT; TO-252

Connections:
+3.3A: C115.1, U26.5 (OUT); also elsewhere on the board
+5: C113.1, C114.1, U25.2 (OUT), U26.1 (IN); also elsewhere on the board
/Microcontroller/TEMP_V5: U27.2 (OUT); also elsewhere on the board
/Microcontroller/TEMP_VRELAY: U24.2 (OUT); also elsewhere on the board
/Power/VRHS: C108.1, D7.2, MP1.1, R146.1, U23.3 (OUT)
unnamed: E4.1, J11.1
unnamed: E5.1, J11.4
unnamed: R146.2, R147.1, U23.1
unnamed: R148.2, U26.6 (EN)
VRELAY: D7.1; also elsewhere on the board

Notes on the sheet:
The analog 3.3V rail is enabled by the digital 3.3V rail, so the DAC is not powered if separate analog power cable is disconnected. @R148 forms a low-pass filter with the input and output capacitors to prevent injection of noise from the digital rail.

Parts:
C10, C19: 2u2; CAPMP2013X120
C90, C91: 10n; CAPC1005X55
C92, C98, C99, C103, C104: 100n; CAPC1608X55
C97, C102: 15u/16; CAPMP3528X210
R111, R113, R123, R124: 10k; RESC1005X40
R112, R114: 33k; RESC1005X40
R115, R117, R125, R127: 20k; RESC1005X40
R119, R120, R121, R122, R131, R132: 3k3; RESC1005X40
R126, R128: 820; RESC1005X40
TP2: V1C1; TEST-SMD-SMALL
TP3: V1C2; TEST-SMD-SMALL
U19, U20: MC33078DGK; SOP65P490X109-8

Connections:
+2.5: R121.1, U19.1 (OUT), U19.2 (IN-); also elsewhere on the board
-2.5: C10.2, C19.2, C92.1, R115.2, R117.2, R122.2, R125.1, R127.1, U19.7 (OUT)
/Channel1/VOS1: C90.1, R112.1, TP2.1, U20.1 (OUT); also elsewhere on the board
/Channel1/VOS2: C10.1, R123.1, R125.2, R126.2; also elsewhere on the board
/Channel2/VOS1: C91.1, R114.1, TP3.1, U20.7 (OUT); also elsewhere on the board
/Channel2/VOS2: C19.1, R124.1, R127.2, R128.2; also elsewhere on the board
/Microcontroller/LevelShifters/VOS1_CH1_IN: R111.2; also elsewhere on the board
/Microcontroller/LevelShifters/VOS1_CH2_IN: R113.2; also elsewhere on the board
/Microcontroller/LevelShifters/VOS2_CH1_IN: R123.2; also elsewhere on the board
/Microcontroller/LevelShifters/VOS2_CH2_IN: R124.2; also elsewhere on the board
/Microcontroller/LevelShifters/VREF_IN: U19.3 (IN+); also elsewhere on the board
unnamed: C90.2, R111.1, R112.2, R115.1, U20.2 (IN-)
unnamed: C91.2, R113.1, R114.2, R117.1, U20.6 (IN-)
unnamed: C92.2, R121.2, R122.1, U19.6 (IN-)
unnamed: R119.2, U20.3 (IN+)
unnamed: R120.2, U20.5 (IN+)
unnamed: R131.2, R132.2, U19.5 (IN+)

Notes on the sheet:
-4.125V to 4.125V

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