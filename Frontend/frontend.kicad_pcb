# Repository koson/os (continued)

## KiCad design Frontend/frontend.kicad_pcb (continued)

Board: 4 copper layers, 100.0 x 100.0 mm, 337 parts (73 on the bottom side), 197 nets.

Other parts of the board:
C48: 100p; CAPC2012X70
C58: 33u/16; CAPMP7343X310
R52, R53, R54: 5M23; RESC2012X50

Their connections:
unnamed 92: C48.1, R54.1; also elsewhere on the board
unnamed 93: R52.2; also elsewhere on the board
unnamed: R52.1, R53.2
unnamed: R53.1, R54.2

## KiCad design os-backplane.kicad_pcb

File README.rst:

I'm building an oscilloscope!

See the `project page`_.

.. _`project page`: http://cpavlina.github.io/os/

Parts:
C1: 100n; CAPC2012X70
J1: FPANEL; CONN-MOLEX-52808-1071
MP1, MP2, MP3, MP4: SCREW; SCREW-4-SUPPORTED
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: 3k3; RESC1005X40
R16, R20, R24, R28, R32, R36, R40, R44, R48: 91k; RESC1005X40
R17, R18, R21, R22, R25, R26, R29, R30, R33, R34, R37, R38, R41, R42, R45, R46, R49, R50: 51; RESC1005X40
R19, R23, R27, R31, R35, R39, R43, R47, R51: 56k; RESC1005X40
SLOT0: CPU; CONN-10018783-10202TLF-PCIEx8-FCI
SLOT1: VIDEO; CONN-10018784-10201TLF-PCIEx4-FCI
SLOT2: ACQ; CONN-10018784-10201TLF-PCIEx4-FCI
SLOT3, SLOT4, SLOT5: FREE; CONN-10018784-10201TLF-PCIEx4-FCI
SLOT6: FRONTEND; CONN-10018784-10201TLF-PCIEx4-FCI

Connections:
+3.3: J1.6, R16.1, R20.1, R24.1, R28.1, R32.1, R36.1, R40.1, R44.1, R48.1, SLOT0.A9, SLOT0.A10, SLOT0.B8, SLOT0.B9, SLOT1.A9, SLOT1.A10, SLOT1.B8, SLOT1.B9, SLOT2.A9, SLOT2.A10, SLOT2.B8, SLOT2.B9, SLOT3.A9, SLOT3.A10, SLOT3.B8, SLOT3.B9, SLOT4.A9, SLOT4.A10, SLOT4.B8, SLOT4.B9, SLOT5.A9, SLOT5.A10, SLOT5.B8, SLOT5.B9, SLOT6.A9, SLOT6.A10, SLOT6.B8, SLOT6.B9; also elsewhere on the board
+3.3SB: C1.1, J1.4, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, SLOT0.B10, SLOT1.B10, SLOT2.B10, SLOT3.B10, SLOT4.B10, SLOT5.B10, SLOT6.B10; also elsewhere on the board
+12: J1.1, SLOT0.A2, SLOT0.A3, SLOT0.B1, SLOT0.B2, SLOT0.B3, SLOT1.A2, SLOT1.A3, SLOT1.B1, SLOT1.B2, SLOT1.B3, SLOT2.A2, SLOT2.A3, SLOT2.B1, SLOT2.B2, SLOT2.B3, SLOT3.A2, SLOT3.A3, SLOT3.B1, SLOT3.B2, SLOT3.B3, SLOT4.A2, SLOT4.A3, SLOT4.B1, SLOT4.B2, SLOT4.B3, SLOT5.A2, SLOT5.A3, SLOT5.B1, SLOT5.B2, SLOT5.B3, SLOT6.A2, SLOT6.A3, SLOT6.B1, SLOT6.B2, SLOT6.B3; also elsewhere on the board
/#IRQ_1: R2.1, SLOT0.B34, SLOT1.B11
/#IRQ_2: R3.1, SLOT0.B36, SLOT2.B11
/#IRQ_3: R4.1, SLOT0.B38, SLOT3.B11
/#IRQ_4: R5.1, SLOT0.B40, SLOT4.B11
/#IRQ_5: R6.1, SLOT0.B42, SLOT5.B11
/#IRQ_6: R7.1, SLOT0.B44, SLOT6.B11
/#IRQ_FP: J1.2, R1.1, SLOT0.A36
/#PERST: SLOT0.A11, SLOT1.A11, SLOT2.A11, SLOT3.A11, SLOT4.A11, SLOT5.A11, SLOT6.A11
/#PRSNT_1: R8.1, SLOT0.A33, SLOT1.A1
/#PRSNT_2: R9.1, SLOT0.A35, SLOT2.A1
/#PRSNT_3: R10.1, SLOT0.A37, SLOT3.A1
/#PRSNT_4: R11.1, SLOT0.A39, SLOT4.A1
/#PRSNT_5: R12.1, SLOT0.A41, SLOT5.A1
/#PRSNT_6: R13.1, SLOT0.A43, SLOT6.A1
/BUS0+: R17.2, R18.2, R19.1, SLOT0.B14, SLOT1.B14, SLOT2.B14, SLOT3.B14, SLOT4.B14, SLOT5.B14, SLOT6.B14
/BUS0-: R16.2, R17.1, R18.1, SLOT0.B15, SLOT1.B15, SLOT2.B15, SLOT3.B15, SLOT4.B15, SLOT5.B15, SLOT6.B15
/BUS1+: R21.2, R22.2, R23.1, SLOT0.A16, SLOT1.A16, SLOT2.A16, SLOT3.A16, SLOT4.A16, SLOT5.A16, SLOT6.A16
/BUS1-: R20.2, R21.1, R22.1, SLOT0.A17, SLOT1.A17, SLOT2.A17, SLOT3.A17, SLOT4.A17, SLOT5.A17, SLOT6.A17
/BUS2+: R25.2, R26.2, R27.1, SLOT0.B19, SLOT1.B19, SLOT2.B19, SLOT3.B19, SLOT4.B19, SLOT5.B19, SLOT6.B19
/BUS2-: R24.2, R25.1, R26.1, SLOT0.B20, SLOT1.B20, SLOT2.B20, SLOT3.B20, SLOT4.B20, SLOT5.B20, SLOT6.B20
/BUS3+: R29.2, R30.2, R31.1, SLOT0.A21, SLOT1.A21, SLOT2.A21, SLOT3.A21, SLOT4.A21, SLOT5.A21, SLOT6.A21
/BUS3-: R28.2, R29.1, R30.1, SLOT0.A22, SLOT1.A22, SLOT2.A22, SLOT3.A22, SLOT4.A22, SLOT5.A22, SLOT6.A22
/BUS4+: R33.2, R34.2, R35.1, SLOT0.B23, SLOT1.B23, SLOT2.B23, SLOT3.B23, SLOT4.B23, SLOT5.B23, SLOT6.B23
/BUS4-: R32.2, R33.1, R34.1, SLOT0.B24, SLOT1.B24, SLOT2.B24, SLOT3.B24, SLOT4.B24, SLOT5.B24, SLOT6.B24
/BUS5+: R37.2, R38.2, R39.1, SLOT0.A25, SLOT1.A25, SLOT2.A25, SLOT3.A25, SLOT4.A25, SLOT5.A25, SLOT6.A25
/BUS5-: R36.2, R37.1, R38.1, SLOT0.A26, SLOT1.A26, SLOT2.A26, SLOT3.A26, SLOT4.A26, SLOT5.A26, SLOT6.A26
/BUS6+: R41.2, R42.2, R43.1, SLOT0.B27, SLOT1.B27, SLOT2.B27, SLOT3.B27, SLOT4.B27, SLOT5.B27, SLOT6.B27
/BUS6-: R40.2, R41.1, R42.1, SLOT0.B28, SLOT1.B28, SLOT2.B28, SLOT3.B28, SLOT4.B28, SLOT5.B28, SLOT6.B28
/BUS7+: R45.2, R46.2, R47.1, SLOT0.A29, SLOT1.A29, SLOT2.A29, SLOT3.A29, SLOT4.A29, SLOT5.A29, SLOT6.A29
/BUS7-: R44.2, R45.1, R46.1, SLOT0.A30, SLOT1.A30, SLOT2.A30, SLOT3.A30, SLOT4.A30, SLOT5.A30, SLOT6.A30
/BUS#WR: SLOT0.A32, SLOT1.A32, SLOT2.A32, SLOT3.A32, SLOT4.A32, SLOT5.A32, SLOT6.A32
/BUSCLK+: R49.2, R50.2, R51.1, SLOT0.A13, SLOT1.A13, SLOT2.A13, SLOT3.A13, SLOT4.A13, SLOT5.A13, SLOT6.A13
/BUSCLK-: R48.2, R49.1, R50.1, SLOT0.A14, SLOT1.A14, SLOT2.A14, SLOT3.A14, SLOT4.A14, SLOT5.A14, SLOT6.A14
/BUS_#RD: SLOT0.B30, SLOT1.B30, SLOT2.B30, SLOT3.B30, SLOT4.B30, SLOT5.B30, SLOT6.B30
/BUS_ADR_#DAT: SLOT0.B12, SLOT1.B12, SLOT2.B12, SLOT3.B12, SLOT4.B12, SLOT5.B12, SLOT6.B12
/I2C_SCL: R15.1, SLOT0.B6, SLOT1.B6, SLOT2.B6, SLOT3.B6, SLOT4.B6, SLOT5.B6, SLOT6.B6
/I2C_SDA: R14.1, SLOT0.B5, SLOT1.B5, SLOT2.B5, SLOT3.B5, SLOT4.B5, SLOT5.B5, SLOT6.B5
/Power/3V3EN: SLOT0.A48; also elsewhere on the board
/Power/12VEN: SLOT0.A38; also elsewhere on the board
/Power/FAN: SLOT0.B46; also elsewhere on the board
/SPI_#CS_1: SLOT0.B33, SLOT1.A8
/SPI_#CS_2: SLOT0.B35, SLOT2.A8
/SPI_#CS_3: SLOT0.B37, SLOT3.A8
/SPI_#CS_4: SLOT0.B39, SLOT4.A8
/SPI_#CS_5: SLOT0.B41, SLOT5.A8
/SPI_#CS_6: SLOT0.B43, SLOT6.A8
/SPI_#CS_FP: J1.3, SLOT0.A34
/SPI_CLK: J1.9, SLOT0.A5, SLOT1.A5, SLOT2.A5, SLOT3.A5, SLOT4.A5, SLOT5.A5, SLOT6.A5
/SPI_MISO: J1.5, SLOT0.A7, SLOT1.A7, SLOT2.A7, SLOT3.A7, SLOT4.A7, SLOT5.A7, SLOT6.A7
/SPI_MOSI: J1.7, SLOT0.A6, SLOT1.A6, SLOT2.A6, SLOT3.A6, SLOT4.A6, SLOT5.A6, SLOT6.A6
GND: C1.2, J1.8, J1.10, MP1.1, MP2.1, MP3.1, MP4.1, R19.2, R23.2, R27.2, R31.2, R35.2, R39.2, R43.2, R47.2, R51.2, SLOT0.A4, SLOT0.A12, SLOT0.A15, SLOT0.A18, SLOT0.A20, SLOT0.A23, SLOT0.A24, SLOT0.A27, SLOT0.A28, SLOT0.A31, SLOT0.B4, SLOT0.B7, SLOT0.B13, SLOT0.B16, SLOT0.B18, SLOT0.B21, SLOT0.B22, SLOT0.B25, SLOT0.B26, SLOT0.B29, SLOT0.B31, SLOT0.B32, SLOT1.A4, SLOT1.A12, SLOT1.A15, SLOT1.A18, SLOT1.A20, SLOT1.A23, SLOT1.A24, SLOT1.A27, SLOT1.A28, SLOT1.A31, SLOT1.B4, SLOT1.B7, SLOT1.B13, SLOT1.B16, SLOT1.B18, SLOT1.B21, SLOT1.B22, SLOT1.B25, SLOT1.B26, SLOT1.B29, SLOT1.B31, SLOT1.B32, SLOT2.A4, SLOT2.A12, SLOT2.A15, SLOT2.A18, SLOT2.A20, SLOT2.A23, SLOT2.A24, SLOT2.A27, SLOT2.A28, SLOT2.A31, SLOT2.B4, SLOT2.B7, SLOT2.B13, SLOT2.B16, SLOT2.B18, SLOT2.B21, SLOT2.B22, SLOT2.B25, SLOT2.B26, SLOT2.B29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; also elsewhere on the board

Notes on the sheet:
reserved
Cable: 0152670251

Parts:
C2, C3, C4, C5: 22u / 35; C-ALUM-6.3mm; Rating OS-CON / 2.6A
C6: 100u; CAPAE660X570
C7: 470n; CAPC2012X70
C8: 22n; CAPC2012X70
C9: 1u; CAPC4532X180
C10: 1n; CAPC1005X55
C11: 47u; CAPAE660X570
C12: 10n; CAPC1005X55
D1, D2: MBR0540; SOD-123
DZ1: 3V9; SOT-23
J2: FAN; CONN-100MIL-M-1x3
J3: PWR; CONN-100MIL-M-1x3
L1: 1m; BOURNS-RLB0914
Q1: IRFML8244; SOT-23
Q2, Q3: AOD4189; TO-252
Q4: MMBT3906; SOT-23
Q5, Q6: MMBT3904; SOT-23
R52: 3k3; RESC1005X40
R53, R55: 1M; RESC1005X40
R54: 470; RESC1005X40
R56: 10k; RESC1005X40
R57: 1k; RESC1005X40
R58: 4R7; RESC3216X60
RT1: 30R500; LITTELFUSE-30R500

Connections:
+3.3SB: C11.1, Q5.2, Q6.2, R52.1, R58.1; also elsewhere on the board
+12: C6.1, D1.1, J2.2; also elsewhere on the board
/Power/3SBCS: L1.1, Q5.1, R58.2
/Power/3SBSW: C10.1, D2.1, L1.2, Q4.3
/Power/FAN: Q1.1, R52.2; also elsewhere on the board
/Power/Supply12V/VIN: C2.1, C3.1, C4.1, C5.1, C8.1, C9.1, Q3.3 (D), Q4.2, R54.1, R56.1; also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C11.2, C12.2, D2.2, DZ1.1, J3.1, J3.3, Q1.2, R55.2; also elsewhere on the board
unnamed: C7.1, Q2.2 (S), Q3.2 (S), R53.1
unnamed: C7.2, C8.2, Q2.1 (G), Q3.1 (G), R53.2, R55.1
unnamed: C10.2, C12.1, DZ1.3, Q5.3, Q6.1, R56.2
unnamed: D1.2, J2.1, J2.3, Q1.3
unnamed: J3.2, RT1.1
unnamed: Q2.3 (D), RT1.2
unnamed: Q4.1, R54.2, R57.1
unnamed: Q6.3, R57.2

Notes on the sheet:
Backplane power supply --------------------------------------- Input: 15 to 25V, 65W Outputs: 12V, 60W / 5A 3V3, 25W / 7.5A 3V3, 330mW / 100mA Combined output power must not exceed 60W The input capacitors are ultra low-impedance types and are shared among both high-power supplies.

Parts:
C13, C15: 1u; CAPC2012X70
C14, C17: 100n; CAPC2012X70
C16: 390p; CAPC1005X55
C18: 10n; CAPC1608X55
C19: 82u / 16; CAPAE530X540; Rating OS-CON, 3A, ESR=R027
C20: 1u; CAPC4532X180
C21: 120p; CAPC1005X55
C22: 1n5; CAPC1005X55
D3: MBR0540; SOD-123
JP1: BYP; CONN-100MIL-M-1x3
L2: 8u2; BOURNS-SRP1238A
Q7, Q9: CSD18504Q5A; TEXAS-Q5A
Q8: BSS138; SOT-23
R59: 27k4; RESC1005X40
R60: 3k09; RESC1005X40
R61, R62: 130k; RESC1005X40
R63: 475k; RESC1005X40
R64: 8k87; RESC1005X40
R65: 20k; RESC1005X40
R66: 1R; RESC1005X40
R67: R007; CAPC1632X76
R68: 19k1; RESC1005X40
R69: 9k76; RESC1005X40
R70: 1k1; RESC1005X40
U1: LM25116MHX; SOP65P640X110-21
W1, W2: NET-TIE; NET-TIE-0.3mm

Connections:
+12: C19.1, L2.1, R69.2, U1.10 (VOUT); also elsewhere on the board
/Power/12VEN: JP1.1; also elsewhere on the board
/Power/Supply12V/AGND: C16.2, C18.2, R64.2, R70.2, U1.6 (AGND), W2.1
/Power/Supply12V/CS+: Q9.1, Q9.2, Q9.3, R66.1, R67.1, U1.12 (CS)
/Power/Supply12V/CS-: R66.2, U1.11 (DEMB), U1.13 (CSG), W1.1
/Power/Supply12V/EN: Q8.3, R62.2, U1.4 (EN)
/Power/Supply12V/FB: C21.2, C22.2, R69.1, R70.1, U1.8 (FB)
/Power/Supply12V/HGATE: Q7.4, U1.19 (HO)
/Power/Supply12V/LGATE: Q9.4, U1.15 (LO)
/Power/Supply12V/SW: C15.2, L2.2, Q7.1, Q7.2, Q7.3, Q9.5, Q9.6, Q9.7, Q9.8, U1.20 (SW)
/Power/Supply12V/VCC: C13.1, D3.2, R63.1, U1.16 (VCC)
/Power/Supply12V/VIN: C14.1, C20.1, Q7.5, Q7.6, Q7.7, Q7.8, R59.1, R61.1, R62.1, U1.1 (VIN); also elsewhere on the board
GND: C13.2, C14.2, C17.2, C19.2, C20.2, JP1.3, Q8.2, R60.2, R65.2, R67.2, U1.14 (PGND), U1.17 (VCCX), U1.21 (EP), W1.2, W2.2; also elsewhere on the board
unnamed: C15.1, D3.1, U1.18 (HB)
unnamed: C16.1, R63.2, U1.5 (RAMP)
unnamed: C17.1, JP1.2, Q8.1, R61.2, R65.1
unnamed: C18.1, U1.7 (SS)
unnamed: C21.1, R68.1, U1.9 (COMP)
unnamed: C22.1, R68.2
unnamed: R59.2, R60.1, U1.2 (UVLO)
unnamed: R64.1, U1.3 (RT/SYNC)

Notes on the sheet:
Alternatives: MAX8546

Parts:
C23, C28: 100n; CAPC2012X70
C24: 470n; CAPC2012X70
C25: 22n; CAPC2012X70
C26: 47n; CAPC1608X55
C27: 150p; CAPC1005X55
C29: 10n; CAPC1608X55
C30: 2n2; CAPC1608X55
C31: 330u; CAPAE1030X1250
C32: 1u; CAPC4532X180
C33: 330p; CAPC1005X55
C34: 2n2; CAPC1005X55
D4: MBR1635G; TO-220-2
JP2: BYP; CONN-100MIL-M-1x3
L3: 2u2; BOURNS-SRP1238A
Q10: CSD18503Q5A; TEXAS-Q5A
Q11: BSS138; SOT-23
R71: 49k9; RESC1005X40
R72: 130k; RESC1005X40
R73: 5k62; RESC1005X40
R74: 1M; RESC1005X40
R75: 6R8; RESC6432X70
R76: 10k7; RESC1005X40
R77: 20k; RESC1005X40
R78: 1R; RESC1005X40
R79: R008; CAPC1632X76
R80: 25k5; RESC1005X40
R81: 3k32; RESC1005X40
R82: 1k91; RESC1005X40
U2: LM25088-1MH; SOP65P640X110-17
W3, W4: NET-TIE; NET-TIE-0.3mm

Connections:
+3.3: C31.1, L3.1, R81.2, U2.9 (VOUT); also elsewhere on the board
/Power/3V3EN: JP2.1; also elsewhere on the board
/Power/Supply3V3/AGND: C26.2, C27.2, C29.2, R76.2, R82.2, W4.1
/Power/Supply3V3/CS+: C30.2, D4.2, R78.1, R79.1, U2.12 (CS)
/Power/Supply3V3/CS-: R78.2, U2.11 (CSG), W3.1
/Power/Supply3V3/EN: Q11.3, R71.2, R73.1, U2.2 (EN)
/Power/Supply3V3/FB: C33.2, C34.2, R81.1, R82.1, U2.8 (FB)
/Power/Supply3V3/HGATE: Q10.4, U2.14 (HG)
/Power/Supply3V3/SW: C25.2, D4.1, L3.2, Q10.1, Q10.2, Q10.3, R75.1, U2.13 (SW)
/Power/Supply3V3/VCC: C24.1, R74.1, U2.16 (VCC)
/Power/Supply12V/VIN: C23.1, C32.1, Q10.5, Q10.6, Q10.7, Q10.8, R71.1, R72.1, U2.1 (VIN); also elsewhere on the board
GND: C23.2, C24.2, C28.2, C31.2, C32.2, JP2.3, Q11.2, R73.2, R77.2, R79.2, U2.6 (PGND), U2.17 (EP), W3.2, W4.2; also elsewhere on the board
unnamed: C25.1, U2.15 (BOOT)
unnamed: C26.1, U2.10 (DITH/RES)
unnamed: C27.1, R74.2, U2.4 (RAMP)
unnamed: C28.1, JP2.2, Q11.1, R72.2, R77.1
unnamed: C29.1, U2.3 (SS)
unnamed: C30.1, R75.2
unnamed: C33.1, R80.1, U2.7 (COMP)
unnamed: C34.1, R80.2
unnamed: R76.1, U2.5 (RT)

Notes on the sheet:
Possible replacements: LTC3851EUD

Board: 4 copper layers, 195.0 x 95.0 mm, 160 parts (27 on the bottom side), 99 nets.

Other parts of the board:
MP5, MP6: SCREW; SCREW-4-SUPPORTED
TP1: 3V3; TEST-PTH
TP2: 12V; TEST-PTH

Their connections:
+3.3: TP1.1; also elsewhere on the board
+12: TP2.1; also elsewhere on the board
GND: MP5.1, MP6.1; also elsewhere on the board
