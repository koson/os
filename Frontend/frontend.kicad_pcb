# Repository koson/os (continued)

## KiCad design PSU3V3/psu3v3.kicad_pcb

Board: 2 copper layers, 68.0 x 43.0 mm, 22 parts (0 on the bottom side), 14 nets.

Parts:
C1, C3: 22u; CAPAE660X570
C2: 10n; CAPC2012X70
C4: 6u8; CAPC3225X88
C5: 150u; CAPAE1030X1250
C6: 22u; CAPC3216X70
D1: STPS10L25G; TO-263
J1: IN; CONN-100MIL-M-1x4
J2: OUT; CONN-100MIL-M-1x8
L1, L4: 1u; BOURNS-SRR1210
L2, L3: 8u2; BOURNS-SRP1238A
Q1: AOD417; TO-252
Q2: IPD50P04P4L-11; TO-252
Q3, Q4: MMUN2231L; SOT-23
R1: 10k; RESC2012X50
R2: 1k54; RESC2012X50
R3: 3k3; RESC2012X50
R4: 978; RESC2012X50
U1: LM22676QTJ-ADJ; TO-263-7-TEXAS

Connections:
/3V3: J2.4, J2.5, Q2.3
/3V3FILT: C6.1, J2.3, L4.1, Q2.2, R3.1
/3V3IN: C3.1, C4.1, L1.1, L2.2, U1.2
/3V3UF: C5.1, L3.1, L4.2, R2.1
/12V: J2.1, J2.2, Q1.3
/12VFILT: C1.1, L2.1, Q1.2, R1.1
/ENABLE: J2.6, Q3.1, Q4.1
/FBK: R2.2, R4.1, U1.6
/SW: C2.1, D1.3, L3.2, U1.1
/VIN: J1.1, J1.2, L1.2
GND: C1.2, C3.2, C4.2, C5.2, C6.2, D1.2, J1.3, J1.4, J2.7, J2.8, Q3.2, Q4.2, R4.2, U1.4, U1.8
unnamed: C2.2, U1.3
unnamed: Q1.1, Q3.3, R1.2
unnamed: Q2.1, Q4.3, R3.2

## Code that names these connections

File Frontend-FW/osfe.ioc (part):

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Mcu.Name=STM32F030C8Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F030C8Tx
PA0.Mode=IN0
PA0.Signal=ADC_IN0
PA1.Mode=IN1
PA1.Signal=ADC_IN1
PA10.Signal=GPIO_Output
PA11.Signal=GPIO_Output
PA12.Signal=GPIO_Output
PA13.Mode=Serial-WireDebug
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial-WireDebug
PA14.Signal=SYS_SWCLK
PA15.Mode=NSS_Signal_Hard
PA15.Signal=SPI1_NSS
PA2.Mode=IN2
PA2.Signal=ADC_IN2
PA3.Mode=IN3
PA3.Signal=ADC_IN3
PA4.Mode=IN4
PA4.Signal=ADC_IN4
PA5.Mode=IN5
PA5.Signal=ADC_IN5
PA6.Signal=GPIO_Output
PA7.Signal=GPIO_Input
PA9.Mode=Half_duplex(single_wire_mode)
PA9.Signal=USART1_TX
PB0.Signal=GPIO_Output
PB1.Signal=GPIO_Output
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB12.Mode=NSS_Signal_Hard
PB12.Signal=SPI2_NSS
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.Signal=GPIO_Output
PB3.Mode=Full_Duplex_Slave
PB3.Signal=SPI1_SCK
PB4.Mode=Full_Duplex_Slave
PB4.Signal=SPI1_MISO
PB5.Mode=Full_Duplex_Slave
PB5.Signal=SPI1_MOSI
PB6.Signal=GPIO_Output
PB7.Signal=GPIO_Output
PB8.Signal=GPIO_Output
PC13.Signal=GPIO_Output
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.Signal=GPIO_Output
RCC.SYSCLKFreq_VALUE=24000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK

File Frontend-FW/pins.h:

// Named pin definitions

#ifndef _PINS_H
#define _PINS_H 1

#include <stm32f030x6.h>

#define nIRQ_PIN    6
#define nIRQ_PORT   GPIOA

#define nPERST_PIN  7
#define nPERST_PORT GPIOA

#define nCSDAC_PIN  15
#define nCSDAC_PORT GPIOA

#define CH1_TERM_PIN    8
#define CH1_TERM_PORT   GPIOB
#define CH1_DC_PIN      7
#define CH1_DC_PORT     GPIOB
#define CH1_ATT1_PIN    6
#define CH1_ATT1_PORT   GPIOB
#define CH1_ATT2_PIN    1
#define CH1_ATT2_PORT   GPIOB
#define CH1_GAIN1_PIN   0
#define CH1_GAIN1_PORT  GPIOB
#define CH1_GAIN2_PIN   2
#define CH1_GAIN2_PORT  GPIOB

#define CH2_TERM_PIN    10
#define CH2_TERM_PORT   GPIOA
#define CH2_DC_PIN      11
#define CH2_DC_PORT     GPIOA
#define CH2_ATT1_PIN    12
#define CH2_ATT1_PORT   GPIOA
#define CH2_ATT2_PIN    13
#define CH2_ATT2_PORT   GPIOC
#define CH2_GAIN1_PIN   15
#define CH2_GAIN1_PORT  GPIOC
#define CH2_GAIN2_PIN   14
#define CH2_GAIN2_PORT  GPIOC

#endif // _PINS_H

## Commit log

2015-02-08 Initial checkin
2015-02-08 Reannotated parts
2015-02-08 Added license and readme
2015-02-08 Added extra supports
2015-02-09 Added Easter egg
2015-02-09 Silkscreen and 3D touchups
2015-02-09 Researched alternative DC-DC controllers
2015-02-09 Changed BSS138 to MMUN221
2015-02-09 Added auto-renders
2015-02-09 Added readme
2015-02-09 Corrected thermal reliefs
2015-02-10 Added power supply load test points
2015-02-15 Updated to reflect new username
2015-02-15 Reorganized to single repository
2015-02-15 Create gh-pages branch via GitHub
2015-02-15 Added frontend block diagram
2015-02-15 Rename Common-kicad to Common-lib
2015-02-15 Frontend work
2015-02-15 Modified readme
2015-02-15 Removed download links as this is not a software project
2015-02-15 Added stuff!
2015-02-15 Corrected typo
2015-02-15 Added input atten/amp simulation
2015-02-16 Added attenuator schematic
2015-02-16 Wrote up attenuator
2015-02-16 Migrate to Jekyll
2015-02-16 Style changes
2015-02-16 Configured posts
2015-02-16 Oh bloody hell.
2015-02-16 More bloody hell
2015-02-16 Oh ffs.
2015-02-23 Finished to send to fab
2015-02-25 Frontend amplifier section
2015-02-26 Updated frontend drawings
2015-02-26 Corrected reference designator K3->K4
2015-02-26 Changed frontend description
2015-02-26 Style change
2015-05-10 Frontend schematic ready to go to layout
2015-05-11 Route PCB
2015-05-12 Work more on routing
2015-05-15 More layout work
2015-05-15 Schematic touchups
2015-05-15 Route #IRQ and #PERST
2015-05-15 Remove old schematic file
2015-05-15 Reannotate schematic/PCB
2015-05-16 Add bypass capacitor around AC coupling capacitors
2015-05-16 Reannotate after adding parts
2015-05-16 Open mask under thermal pads
2015-05-16 Add testpoints
2015-05-16 Digital decoupling/termination tweaks
2015-05-18 Schematic cleanup
2015-05-18 Cleanup offset compensation system
2015-05-25 Even more layout tweaks
2015-05-25 Switch acq connectors to SATA
2015-05-25 Fix final gain stage resistors
2015-05-28 More routing adjustments
2015-05-28 Update gerbers
2015-05-29 Finally finish the final layout finally
2015-05-29 Begin firmware
2015-05-30 Write build system
2015-05-30 Add pin definitions
